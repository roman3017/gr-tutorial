<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>max_nouts</key><value>fft_size</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>tutorial_openbci_py_i</key>
<param><key>id</key><value>tutorial_openbci_py_i_0</value></param>
<param><key>port</key><value>/dev/ttyUSB0</value></param>
</block>
<block>
<key>blocks_int_to_float</key>
<param><key>id</key><value>blocks_int_to_float_0</value></param>
<param><key>scale</key><value>1000000</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>fftsize</key><value>fft_size</value></param>
<param><key>wintype</key><value>firdes.WIN_HAMMING</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>rate</key><value>1</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<connection><source_block_id>blocks_int_to_float_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tutorial_openbci_py_i_0</source_block_id><sink_block_id>blocks_int_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
